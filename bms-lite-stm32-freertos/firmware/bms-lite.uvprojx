# Keil uVision project bms-lite.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
  group FreeRTOS
    ./FreeRTOS/Source/: list.c queue.c tasks.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./FreeRTOS/: FreeRTOSConfig.h
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
